# Keil uVision project project.uvproj, settings and files
target project (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\StdPeriphDriver\inc;.\Users;.\app\gui;.\app\lcd;.\app\led;.\Public;.\app\esp8266\ESP8266_drive;.\app\esp8266\ESP8266_Public;.\app\esp8266\STA_TCPClent_Test;.\lora\drv_mcu\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ./CMSIS/: system_stm32f10x.c core_cm3.c
  group StdPeriphDriver
    ./StdPeriphDriver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_usart.c stm32f10x_tim.c
  group StartUp
    ./StartUp/: startup_stm32f10x_hd.s
  group app
    ./app/gui/: gui.c
    ./app/lcd/: lcd_driver.c
    ./app/led/: led.c
  group User
    ./Users/: main.c stm32f10x_it.c public.c
  group esp8266
    ./app/esp8266/ESP8266_drive/: esp8266_drive.c
    ./app/esp8266/ESP8266_Public/: esp8266_public.c
    ./app/esp8266/STA_TCPClent_Test/: sta_tcpclent_test.c
  group public
    ./Public/: system.c SysTick.c usart.c
  group lora
    ./lora/drv_mcu/src/: drv_delay.c drv_led.c drv_uart.c
